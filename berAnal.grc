options:
  parameters:
    generate_options: qt_gui
    id: berAnal
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: EbN0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '10'
  states: {}
- name: const
  id: variable
  parameters:
    value: (digital.constellation_bpsk(),digital.constellation_qpsk(),digital.constellation_8psk())
  states: {}
- name: const_type
  id: variable
  parameters:
    value: '2'
  states: {}
- name: numpoints
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 1.0/math.sqrt(2.0*const[const_type].bits_per_symbol()*10**(EbN0/10))
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: const[const_type].arity()
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: int
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: int
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '2'
    in_type: int
    out_type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_add_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_1, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
